main:

LDI R16, 0x06
LDI R17, 0x0E
LDI R18, 0xFF
OUT DDRD, R18

L1:
OUT PORTD, R16
CALL delay
CP R16, R17
BREQ end
INC R16
RJMP L1

delay:
LDI R18, 50
LDI R19, 100
LDI R20, 10

L2:
DEC R18
BRNE L2
DEC R19
BRNE L2
DEC R20
BRNE L2
NOP
RET

end:
RJMP main

